<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Dsamp</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Fs1</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Fs2</value></param>
<param><key>value</key><value>4000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Fs3</value></param>
<param><key>value</key><value>64000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Usamp</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>f0</value></param>
<param><key>value</key><value>200</value></param>
<param><key>gui_hint</key><value>(1,1,1,1)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-5000</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>5000</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>fc</value></param>
<param><key>value</key><value>4000</value></param>
<param><key>gui_hint</key><value>(2,1,1,1)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-16000</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>16000</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>k</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>(0,1,1,1)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-1</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pamfunn</value></param>
<param><key>value</key><value>PAM.pam10(Usamp,'sinc',[k,2.6])</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>waveform</value></param>
<param><key>value</key><value>102</value></param>
<param><key>gui_hint</key><value>(0,0,3,1)</value></param>
<param><key>label0</key><value>cosine</value></param>
<param><key>label1</key><value>rect</value></param>
<param><key>label2</key><value>tri</value></param>
<param><key>num_opts</key><value>3</value></param>
<param><key>option0</key><value>102</value></param>
<param><key>option1</key><value>103</value></param>
<param><key>option2</key><value>104</value></param>
<param><key>type</key><value>raw</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>epy_module</key>
<param><key>id</key><value>PAM</value></param>
<param><key>source_code</key><value># this module will be imported in the into your flowgraph
# File: pamfun.py 
# Functions for pulse amplitude modulation (PAM) import numpy as np import comsig
import numpy as np

def pam10(sps, ptype, pparms=[]): 
     
    # ***** Set up PAM pulse p(t) ***** 
    ptype = ptype.lower() # Convert ptype to lowercase
                          # Set left/right limits for p(t) 
    if (ptype=="rect"): 
        kL = -0.5; kR = -kL 
    else: 
        kL = -1.0; kR = -kL # Default left/right limits 
    
    ixpL = int(np.ceil(sps*kL)) # Left index for p(t) time axis 
    ixpR = int(np.ceil(sps*kR)) # Right index for p(t) time axis 
    ttp = np.arange(ixpL,ixpR) # Time axis for p(t) 
    pt = np.zeros(len(ttp)) # Initialize pulse p(t) 
    if (ptype=="rect"): # Rectangular p(t) 
        pt = np.ones(len(ttp))
    elif (ptype == "tri"):
	pt = np.array([(1+i/sps) if i/sps+1 &lt; 1.0 else (1-i/sps) for i in list(ttp)]) 
    elif (ptype=="sinc"):
        k=pparms[0]
        kL = -1.0*k
        kR = -kL
        ixpL = int(np.ceil(sps*kL)) 		# Left index for p(t) time axis
        ixpR = int(np.ceil(sps*kR))		# Right index for p(t) time axis
        ttp = np.arange(ixpL,ixpR)	 # Time axis for p(t)
        pt = np.zeros(len(ttp))
        beta=pparms[1]
        pt = np.array([np.sin(np.pi*t/sps)/(np.pi*t/sps) if t!= 0  else  1.0 for t in list(ttp)])
        pt=pt*np.kaiser(len(pt), beta)
    else:
        print("ptype is not recognized")
    # ***** Filter with h(t) = p(t) ***** 
    return(pt)
</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>3800</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>Fs1</value></param>
<param><key>waveform</key><value>waveform</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>4200</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>Fs1</value></param>
<param><key>waveform</key><value>waveform</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>Fs1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>decim</key><value>Dsamp</value></param>
<param><key>taps</key><value>1</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>interp</key><value>Usamp</value></param>
<param><key>taps</key><value>1</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0_0</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value>2*np.cos(2*np.pi*fc/float(Fs3)*np.arange(-k*Usamp,k*Usamp))*pamfunn</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>np</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>gui_hint</key><value>(4,0,1,1)</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"DT waveform Upsampled at Fs3"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>Fs3</value></param>
<param><key>stemplot</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value>x[n/Usamp]</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>gui_hint</key><value>(3,0,1,1)</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Original 'CT' waveform (at Fs1)"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>32000</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_1</value></param>
<param><key>gui_hint</key><value>(3,1,1,1)</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Dt waveform, sampled at Fs2"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>Fs2</value></param>
<param><key>stemplot</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value>x[n]</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_2</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>gui_hint</key><value>(4,1,1,1)</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Reconstructed 'CT' waveform (at Fs3)"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>Fs3</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value>x(t)</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
